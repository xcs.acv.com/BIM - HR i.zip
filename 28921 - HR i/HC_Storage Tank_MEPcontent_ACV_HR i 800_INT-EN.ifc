Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2021-07-02T10:20:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 02 10:20:32 2021 * Host: MBACIU-RO-DE * Database: C:\Users\MBaciu\AppData\Local\Temp\{FD27C0C3-2603-4270-B06F-BA8CE9D9E4B4}\ifc * Database version: 5507 * Database creation date: Fri Jul 02 10:20:31 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Jul 02 10:20:31 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 02 10:20:31 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcTank: HR i 800, HC_Storage Tank_MEPcontent_ACV_HR i_320-800_INT-EN:HR i 800:1303527
In: V00
Type - Material: Color RGB 222-222-222, Color RGB 237-028-036, Color RGB 040-040-040, Color RGB 155-155-155
Type - Dimensions - Depth: 1022 mm; Domestic Cold Water Diameter: 38.1 mm; Domestic Hot Water Auxiliary Diameter: 19.05 mm; Domestic Hot Water Diameter: 38.1 mm; Drain Diameter: 32 mm; Height: 2122 mm; Hydronic Return Diameter: 50.8 mm; Hydronic Supply Diameter: 50.8 mm; Use Nominal Diameter: yes; Width: 982 mm
Type - Electrical - Frequency: 50 Hz; Maximum Supply Power: 1300 W; Rated Current (Fuse): 6 A; Voltage: 230 V
Type - Identity Data - Article Type: HR i 800; Base Family Version: 12.29; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Tank in stainless steel with hand hole for installation on the floor; EMCS Version: 4.0; ETIM Article Class: EC011392; Family Version: 12.17; GLN: 5400891000007; Manufacturer: ACV; Manufacturer URL: https://www.acv.com/international/customer/dl/4910; MEPcontent Class: STORAGE_TANK_HC; Model: HR i 800; OmniClass Number: 23.75.10.34.11; OmniClass Title: Energy Storage Tanks; Revit Version: 2018; Type Name: HR i 800; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Grey: Color RGB 155-155-155
Type - Mechanical - DHW Continuous Flow 60°C: 0.0003875 m3/s; Maximum Supply Temperature (Operating Temperature): 90 kg/K/s3; Max Pressure DHW: 860000 Pa; Max Pressure Heating: 400000 Pa; Total Capacity: 0.8 m3; Weight: 265
Type - Other - Category: Mechanical Equipment; Boiler Diameter: 373.5 mm; Boiler Radius: 491 mm; C: 132 mm; D: 509 mm; E: 1759 mm; Family Name: HC_Storage Tank_MEPcontent_ACV_HR i_320-800_INT-EN; Feet: 186.75 mm; Feet Diameter: 323.46 mm
Type - Text - Article Description: Tank in stainless steel with hand hole for installation on the floor; GTIN: 5400891036839; Manufacturer Art. No.: A1004575; Product Line: HR
Pset_ManufacturerTypeInformation - Manufacturer: ACV
Constraints - Offset: 0 mm
Dimensions - Area: 18.0919 m2; Volume: 1.53363 m3
Identity Data - Mark: 4
Mechanical - Domestic Cold Water Flow: 0 m3/s; Domestic Hot Water Auxiliary Flow: 0 m3/s; Domestic Hot Water Flow: 0 m3/s; Drain Fixture Units: 0; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Hydronic Return,Hydronic Supply,Power,Sanitary,Domestic Hot Water,Domestic Cold Water
Other - Back Clearance Safe: 1000 mm; Family: HC_Storage Tank_MEPcontent_ACV_HR i_320-800_INT-EN: HR i 800; Family and Type: HC_Storage Tank_MEPcontent_ACV_HR i_320-800_INT-EN: HR i 800; Feet Offset Safe: 0 mm; Feet Safe: 15 mm; Left Clearance Safe: 1000 mm; Top Clearance Safe: 330 mm; Total Height: 2122 mm; Type: HC_Storage Tank_MEPcontent_ACV_HR i_320-800_INT-EN: HR i 800; Type Id: HC_Storage Tank_MEPcontent_ACV_HR i_320-800_INT-EN: HR i 800
Phasing - Phase Created: 3. Nieuwbouw
Visibility - Back Clearance: 1000 mm; Feet Offset: 0 mm; Left Clearance: 1000 mm; Service Space: no; Top Clearance: 330 mm
